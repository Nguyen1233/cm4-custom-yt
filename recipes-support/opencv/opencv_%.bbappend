PACKAGECONFIG:append = " ffmpeg "