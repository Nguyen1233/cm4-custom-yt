# Override source to GitHub mirror for reliability
SRC_URI = "git://github.com/qt/qtserialport.git;branch=6.6;protocol=https"
