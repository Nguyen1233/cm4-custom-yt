# Override source to GitHub mirror for reliability
SRC_URI = "git://github.com/qt/qtserialbus.git;branch=6.8.3;protocol=https"
