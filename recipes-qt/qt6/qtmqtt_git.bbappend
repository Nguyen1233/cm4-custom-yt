# Override source to GitHub mirror for reliability
SRC_URI = "git://github.com/qt/qtmqtt.git;branch=6.6;protocol=https"
